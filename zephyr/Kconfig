## zephyr/Kconfig
```kconfig
# SPDX-License-Identifier: Apache-2.0
menuconfig RCLC
        bool "RCLC support"
        help
          This option enables RCLC

if RCLC

endif
```
